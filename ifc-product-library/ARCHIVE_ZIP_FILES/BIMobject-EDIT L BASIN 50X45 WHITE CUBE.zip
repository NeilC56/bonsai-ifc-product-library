Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Basins_Armitage-Shanks_EDIT-L-BASIN-50X45-WHITE-CUBE.ifc
Time: 2020-02-14T16:34:46
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: EDIT L BASIN 50X45 WHITE CUBE
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): EDIT L BASIN 50X45 WHITE CUBE; SKU (BO_prodsku): S0814; ManufacturName (BO_Manufac): Armitage Shanks; BrandUrl (BO_brandurl): http://www.idealspec.co.uk; ProductFamily (BO_prodfam): Edit L; ProductGroup (BO_prodgroup): Washbasin; EditionNumber (BO_edinum): 1; Width (BO_width): 500; Height (BO_height): 160; Depth (BO_depth): 450; Weight (BO_weight): 12.08; QR (BO_boqrurl): http://bimobject.com/armitage-shanks/product/S0814; ProductDataUrl (BO_prodaturl): bimobject.com/armitage-shanks/product/S0814; ProductUrl (BO_producturl): https://www.idealspec.co.uk/catalogue/bluebook/; InstallationInstructions (BO_montins): https://www.idealspec.co.uk/catalogue/bluebook/; TechnicalDescription (BO_techcert): https://www.idealspec.co.uk/catalogue/bluebook/; GtinCode (BO_gtin): 5017830545675; MaterialMain (BO_mainmat): Ceramics; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Basins; BimObjectCategoryCode (BO_bocat_code): sanitary-basins; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspscCode (BO_unspsc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7212; Uniclass14Description (BO_uniclass_1_4_desc): Washbasins; Uniclass20Code (BO_uniclass_2_0_code): PR-31-79; Uniclass20Description (BO_uniclass_2_0_desc): Sinks, Wash Basins And Troughs; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_96_96; Uniclass2015Description (BO_uniclass2015_desc): Wall-hung wash basins; NBSReference (BO_nbs_ref): 31-79; NBSReferenceDescription (BO_nbs_desc): Sinks, Wash Basins And Troughs; OmniClassCode (BO_omniclass_code): 23-39 29 13 21 19; OmniClassDescription (BO_omniclass_name): Surface Water Retention Basins; MasterFormat2014Code (BO_masterformat2014_code): 33 44 13.13; MasterFormat2014Description (BO_masterformat2014_name): Catchbasins; RegionEurope (BO_europe): GB
