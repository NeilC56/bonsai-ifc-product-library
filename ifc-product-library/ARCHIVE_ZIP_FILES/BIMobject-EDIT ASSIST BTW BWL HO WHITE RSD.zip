Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilets_Armitage-Shanks_EDIT-ASSIST-BTW-BWL-HO-WHITE-RSD.ifc
Time: 2020-02-12T09:22:11
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: EDIT ASSIST BTW BWL HO WHITE RSD
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): EDIT ASSIST BTW BWL HO WHITE RSD; SKU (BO_prodsku): S0825; ManufacturName (BO_Manufac): Armitage Shanks; BrandUrl (BO_brandurl): http://www.idealspec.co.uk; ProductFamily (BO_prodfam): Edit Assist; ProductGroup (BO_prodgroup): WC pan; EditionNumber (BO_edinum): 1; Width (BO_width): 550; Height (BO_height): 460; Depth (BO_depth): 360; Weight (BO_weight): 32.7; QR (BO_boqrurl): http://bimobject.com/armitage-shanks/product/S0825; ProductDataUrl (BO_prodaturl): bimobject.com/armitage-shanks/product/S0825; ProductUrl (BO_producturl): https://www.idealspec.co.uk/catalogue/bluebook/; InstallationInstructions (BO_montins): https://www.idealspec.co.uk/catalogue/bluebook/; TechnicalDescription (BO_techcert): https://www.idealspec.co.uk/catalogue/bluebook/; GtinCode (BO_gtin): 5017830545903; MaterialMain (BO_mainmat): Ceramics; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Toilets; BimObjectCategoryCode (BO_bocat_code): sanitary-toilets; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspscCode (BO_unspsc): 30181505; Uniclass14Code (BO_uniclass_1_4_code): L7216; Uniclass14Description (BO_uniclass_1_4_desc): Toilets; Uniclass20Code (BO_uniclass_2_0_code): PR-35-93-94; Uniclass20Description (BO_uniclass_2_0_desc): Wc Pans; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_93_94; Uniclass2015Description (BO_uniclass2015_desc): WC pans; NBSReference (BO_nbs_ref): 35-93-94; NBSReferenceDescription (BO_nbs_desc): Wc Pans; OmniClassCode (BO_omniclass_code): 23-31 19 00; OmniClassDescription (BO_omniclass_name): Toilets; RegionEurope (BO_europe): GB
